# Keil uVision project task02.uvprojx, settings and files
target Task02 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F303VC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: task02
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC,USE_STM32F3_DISCO,
  c misc: --C99
  c include: Inc;Drivers\STM32F3xx_HAL_Driver\Inc;Drivers\BSP\STM32F3-Discovery;Drivers\CMSIS\Device\ST\STM32F3xx\Include;Drivers\CMSIS\Include;StartUp\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Doc
    ./Docs/: direct IO access.txt
  group HAL
    ./Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal_spi.c stm32f3xx_hal_i2c.c
  group BSP
    ./Drivers/BSP/STM32F3-Discovery/: stm32f3xx_it.c
    Drivers/BSP/STM32F3-Discovery/: stm32f3_discovery.c
  group StartUp
    ./StartUp/Src/: board_startup.c
  group RTX
    ./RTX/Src/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c RTX_Conf_CM.c HAL_CM3.c SVC_Table.s
  group Src
    ./Src/: task02.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.3.0
